require u-boot-common.inc
require u-boot-tools.inc

UBOOT_VERSION = "2021.04"

SRCREV = "b46dd116ce03e235f2a7d4843c6278e1da44b5e1"

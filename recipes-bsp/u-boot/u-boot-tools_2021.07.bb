require u-boot-common.inc
require u-boot-tools.inc

UBOOT_VERSION = "2021.07"

SRCREV = "840658b093976390e9537724f802281c9c8439f5"

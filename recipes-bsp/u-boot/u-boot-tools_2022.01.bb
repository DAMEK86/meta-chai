require u-boot-common.inc
require u-boot-tools.inc

UBOOT_VERSION = "2022.01"

SRCREV = "d637294e264adfeb29f390dfc393106fd4d41b17"
